# Keil uVision project Project.uvprojx, settings and files
target AT6010_HTM (6220000::V6.22::ARMCLANG)
  device: PY32F003x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(8000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,PY32F003x8,USE_AT6010_HTM
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\PY32F003xx_Start_Kit;..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_py32f003xx.s
    ../Src/: system_py32f0xx.c
  group Application/User
    ../Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c
  group BSP/py32f003xx_Start_Kit
    ../../../../../../drivers/BSP/PY32F003xx_Start_Kit/: py32f003xx_Start_Kit.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../../../../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c
    ../../../../../../drivers/PY32F0xx_HAL_Driver/src/: py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_dma.c py32f0xx_hal_pwr.c py32f0xx_hal_uart.c py32f0xx_hal_cortex.c
  group Doc
    ../: readme.txt
target AT2410 (6160000::V6.16::ARMCLANG)
  device: PY32F003x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: as above
  output: Project +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,PY32F003x8,USE_AT2410
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 6.1.0
